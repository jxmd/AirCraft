<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Aircopter_V1_Demo_Poj.ewp</path>
  </project>
  <batchBuild />
</workspace>
