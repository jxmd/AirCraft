# IAR project Aircopter_V1_Demo_Poj.ewp, settings and files
configuration Aircopter_V1_Demo_Poj Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F373xC ST STM32F373xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F373xC; USE_FULL_ASSERT; USE_MAGNETOMETER; USE_EKF_ALGORITHM
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F3xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Aircopter_V1_Demo_Poj.bin
  ILINK.IlinkOutputFile: Aircopter_V1_Demo_Poj Configuration.out
  ILINK.IlinkIcfFile: D:\project\Aircopter_V1_Demo\Aircopter_V1_Demo_Poj\EWARM\Aircopter_V1_Demo_Poj.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/iar/: startup_stm32f373xc.s startup_stm32f373xc.s
  group Application/User
    ../Src/: dma.c freertos.c gpio.c i2c.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c tim.c usart.c stm32f3xx_hal_msp.c i2c.c main.c freertos.c dma.c stm32f3xx_it.c gpio.c tim.c usart.c
  group Application/User/Algorithm
    ../Src/Algorithm/: algorithm_ahrs.c algorithm_kalman.c algorithm_matrix.c algorithm_moveAve.c algorithm_pid.c
  group Application/User/Peripherals
    ../Src/Peripherals/: i2c2_sensors.c leds.c tim2_motor.c usart1_dbg.c usart3_ble.c usart_buffer.c
  group Application/
    ./: 
  group Application/
    ./: 
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_tim.c stm32f3xx_hal.c stm32f3xx_hal_pwr.c stm32f3xx_hal_flash.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_i2c.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c timers.c tasks.c croutine.c list.c queue.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portasm.s port.c
  group Middlewares/
    ./: 
